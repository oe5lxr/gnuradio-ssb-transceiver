options:
  parameters:
    author: Alexander Entinger, OE5LXR
    copyright: Alexander Entinger, OE5LXR
    generate_options: qt_gui
    id: weaver_ssb_modulator_real
    output_language: python
    title: Weaver SSB Modulator Real
  states: {}

blocks:
- name: omega_max
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: omega_min
  id: variable
  parameters:
    value: '200'
  states: {}
- name: omega_osc_1
  id: variable
  parameters:
    value: (omega_min + omega_max)/2
  states: {}
- name: omega_osc_2
  id: variable
  parameters:
    value: omega_usb+omega_osc_1
  states: {}
- name: omega_usb
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: omega_osc_1
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: omega_osc_2
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: omega_osc_1
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: omega_osc_2
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: iec958:CARD=USB,DEV=0
    samp_rate: '16000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: omega_max
    interp: '12'
    low_cutoff_freq: omega_min
    samp_rate: sample_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: omega_osc_1
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: omega_osc_1
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    name: f_baseband(t)
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: omega_osc_2
    fftsize: '1024'
    name: f_SSB,USB(t)
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0_1_0, '1']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_1_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_1_0, '0', blocks_add_xx_0, '1']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_xx_0_1, '1']
- [low_pass_filter_1_0, '0', blocks_multiply_xx_0_1_0, '0']

metadata:
  file_format: 1
